# Keil uVision project stm32f4_bootloader.uvprojx, settings and files
target stm32f446re (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_bootloader
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSI_VALUE=16000000 HSE_VALUE=8000000
  c include: .\Inc;.\Drivers\Inc
  memory RVCT4: ROM 0x8000000 size 0x7fff
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Src
    ./Src/: main.c bootloader.c debug.c
  group Inc
    ./Inc/: main.h bootloader.h debug.h
  group drivers
    ./Drivers/Inc/: usart.h rcc.h gpio.h
    ./Drivers/Src/: usart.c rcc.c gpio.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Device:Startup 2.5.0
